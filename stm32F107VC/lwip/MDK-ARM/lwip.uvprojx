# Keil uVision project lwip.uvprojx, settings and files
target lwip (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: lwip
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c include: ../Inc;     ../Middlewares/Third_Party/LwIP/src/include;     ../Middlewares/Third_Party/LwIP/system;     ../Drivers/STM32F1xx_HAL_Driver/Inc;     ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;     ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;     ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;     ../Middlewares/Third_Party/LwIP/src/include/lwip;     ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;     ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;     ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;     ../Middlewares/Third_Party/LwIP/src/include/netif;     ../Middlewares/Third_Party/LwIP/src/include/posix;     ../Middlewares/Third_Party/LwIP/src/include/posix/sys;     ../Middlewares/Third_Party/LwIP/system/arch;     ../Drivers/CMSIS/Include;    ../Middlewares/Third_Party/LwIP/src/apps/httpd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Application/User
    ../Src/: lwip.c main.c ethernetif.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ecp.c eui64.c pppol2tp.c ipv6cp.c demand.c eap.c upap.c mppe.c chap-md5.c fsm.c pppapi.c pppos.c pppoe.c ppp.c ipcp.c chap_ms.c multilink.c ccp.c vj.c auth.c lcp.c pppcrypt.c chap-new.c utils.c magic.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c igmp.c ip4_addr.c autoip.c etharp.c dhcp.c icmp.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ip6_frag.c nd6.c mld6.c ip6.c ethip6.c inet6.c ip6_addr.c icmp6.c
    ../Middlewares/Third_Party/LwIP/src/core/: mem.c stats.c tcp.c raw.c def.c init.c pbuf.c timeouts.c memp.c ip.c sys.c tcp_in.c netif.c inet_chksum.c udp.c dns.c tcp_out.c
    ../Middlewares/Third_Party/LwIP/src/api/: netbuf.c api_msg.c tcpip.c netifapi.c netdb.c err.c sockets.c api_lib.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/apps/httpd/: httpd.c fs.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_eth.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c
software components: CMSIS:CORE 4.3.0
